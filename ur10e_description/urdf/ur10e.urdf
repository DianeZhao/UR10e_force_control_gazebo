Commit message: position only and pose cartesian doesn't work at all

File: ur10e_description/urdf/ur10e.urdf (robot description, URDF)
Before this commit: robot ur10e, 9 links, 8 joints
Joints:
- joint world_to_ur10e: origin xyz=0 0 1.5 rpy=0 0 0 -> xyz=0 0 0 rpy=0 0 0
